# Keil uVision project H7PI_Samples.uvprojx, settings and files
target H7PI_Samples (6100001::V6.10.1::.\ARMCLANG)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: H7PI_Samples +hex
  c flags: Optim=6 OneElfS=1 uC99=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx,USE_HAL_DRIVER,STM32H750xx
  c include: ..\User\Drivers\USB;    ../Core/Inc;    ../Drivers/STM32H7xx_HAL_Driver/Inc;    ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;    ../Drivers/CMSIS/Include;    ..\User\Drivers;    ..\User\Drivers\FATFS;    ..\User;    ..\User\Arduino
  memory RVCT4: ROM 0x90000000 size 0x800000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c dac.c dma.c fmc.c i2c.c quadspi.c sdmmc.c spi.c tim.c usart.c usb_otg.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sram.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_qspi.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group /User/Drivers
    ../User/Drivers/: spiflash.c
  group /User/Drivers/USB
    ../User/Drivers/USB/: usb_device.c usbd_conf.c usbd_cdc.c usbd_core.c usbd_ctlreq.c usbd_desc.c usbd_ioreq.c usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c usbd_storage_if.c usbd_cdc_if.c usbd_cdc_msc.c
  group /User/Drivers/FATFS
    ../User/Drivers/FATFS/: bsp_driver_sd.c cc936.c diskio.c fatfs.c fatfs_platform.c ff.c ff_gen_drv.c syscall.c sd_diskio.c user_diskio.c
  group /User/Arduino
    ../User/Arduino/: analog.cpp board.cpp dgital.cpp main.cpp print.cpp stream.cpp time.cpp USBSerial.cpp
software components: CMSIS:CORE 5.3.0
